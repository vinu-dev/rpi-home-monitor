# REQ: SWR-046, SWR-050; RISK: RISK-018, RISK-019; SEC: SC-018, SC-019; TEST: TC-043, TC-044
# Override default boot script with A/B partition switching (ADR-0008)
FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
